require libdrm.inc

SRC_URI = "http://dri.freedesktop.org/libdrm/${BP}.tar.xz"
SRC_URI[sha256sum] = "a777bd85f2b5fc9c57f886c82058300578317cafdbc77d0a769d7e9a9567ab88"